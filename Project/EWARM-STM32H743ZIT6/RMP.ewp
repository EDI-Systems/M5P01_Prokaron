# IAR project RMP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; USE_HAL_DRIVER; HSE_VALUE=8000000
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; ..\..\Include; ..\..\..\M0A00_Library\STM32Cube_FW_H7_V1.9.1\Drivers\CMSIS\Include; ..\..\..\M0A00_Library\STM32Cube_FW_H7_V1.9.1\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\M0A00_Library\STM32Cube_FW_H7_V1.9.1\Drivers\STM32H7xx_HAL_Driver\Inc\Conf; ..\..\..\M0A00_Library\STM32Cube_FW_H7_V1.9.1\Drivers\CMSIS\Device\ST\STM32H7xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RMP.srec
  ILINK.IlinkOutputFile: RMP.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group HAL
    ../../../M0A00_Library/STM32Cube_FW_H7_V1.9.1/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h743xx.s
    ../../../M0A00_Library/STM32Cube_FW_H7_V1.9.1/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
    ../../../M0A00_Library/STM32Cube_FW_H7_V1.9.1/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Kernel
    ../../Source/Kernel/: rmp_kernel.c
  group Platform
    ../../Source/Platform/A7M/: rmp_platform_a7m.c rmp_platform_a7m_iccarm.s
  group Test
    ../../Source/Test/: rmp_benchmark.c
