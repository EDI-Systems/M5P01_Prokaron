# IAR project RMP.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: M2351 series Nuvoton M2351 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Include; ..\..\..\M0A00_Library\M2351BSP\Library\CMSIS\Include; ..\..\..\M0A00_Library\M2351BSP\Library\Device\Nuvoton\M2351\Include; ..\..\..\M0A00_Library\M2351BSP\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RMP.bin
  ILINK.IlinkOutputFile: RMP.out
  ILINK.IlinkIcfFile: rmp_platform_m2351kiaae.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group RMP Source
    ../../Source/Kernel/: rmp_kernel.c
    ../../Source/Platform/A8MB/: rmp_platform_a8mb.c rmp_platform_a8mb_iccarm.s
    ../../Source/Test/: rmp_benchmark.c
    ./: rmp_stubs.c
  group Nuvoton BSP
    ../../../M0A00_Library/M2351BSP/Library/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../../M0A00_Library/M2351BSP/Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../M0A00_Library/M2351BSP/Library/StdDriver/src/: clk.c sys.c uart.c timer.c
