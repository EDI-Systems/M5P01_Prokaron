# Keil uVision project RMP.uvprojx, settings and files
target RMP (6230000::V6.23::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x24000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(64000000) ELITTLE
  output: RMP +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32H743xx,USE_HAL_DRIVER,HSE_VALUE="8000000"
  c include: .\;..\..\Include;..\..\..\M0A00_Library\STM32Cube_FW_H7_V1.9.1\Drivers\CMSIS\Include;..\..\..\M0A00_Library\STM32Cube_FW_H7_V1.9.1\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\..\M0A00_Library\STM32Cube_FW_H7_V1.9.1\Drivers\STM32H7xx_HAL_Driver\Inc\Conf;..\..\..\M0A00_Library\STM32Cube_FW_H7_V1.9.1\Drivers\CMSIS\Device\ST\STM32H7xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Kernel
    ../../Source/Kernel/: rmp_kernel.c
  group Platform
    ../../Source/Platform/A7M/: rmp_platform_a7m.c rmp_platform_a7m_armcc.s
  group Lib
    ../../../M0A00_Library/STM32Cube_FW_H7_V1.9.1/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c
    ../../../M0A00_Library/STM32Cube_FW_H7_V1.9.1/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
    ../../../M0A00_Library/STM32Cube_FW_H7_V1.9.1/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Test
    ../../Source/Test/: rmp_benchmark.c
software components: CMSIS:CORE 5.6.0
