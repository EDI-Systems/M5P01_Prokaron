# IAR project RMP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0H3 ST STM32N657X0H3
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; ..\..\Include; ..\..\..\M0A00_Library\STM32Cube_FW_N6_V1.1.0\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\M0A00_Library\STM32Cube_FW_N6_V1.1.0\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\M0A00_Library\STM32Cube_FW_N6_V1.1.0\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\..\M0A00_Library\STM32Cube_FW_N6_V1.1.0\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RMP.srec
  ILINK.IlinkOutputFile: RMP.out
  ILINK.IlinkIcfFile: rmp_platform_stm32n657x0h3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group HAL
    ../../../M0A00_Library/STM32Cube_FW_N6_V1.1.0/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx.s
    ../../../M0A00_Library/STM32Cube_FW_N6_V1.1.0/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c
    ../../../M0A00_Library/STM32Cube_FW_N6_V1.1.0/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_s.c
  group Kernel
    ../../Source/Kernel/: rmp_kernel.c
  group Platform
    ../../Source/Platform/A8MM/: rmp_platform_a8mm.c rmp_platform_a8mm_iccarm.s
  group Test
    ../../Source/Test/: rmp_benchmark.c
