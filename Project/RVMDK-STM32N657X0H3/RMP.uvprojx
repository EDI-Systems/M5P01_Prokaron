# Keil uVision project RMP.uvprojx, settings and files
target RMP (6230000::V6.23::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.2.0
  cpu: IRAM(0x34000400,0xFFC00) CPUTYPE("Cortex-M55") CLOCK(64000000) ELITTLE
  output: RMP +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32N657xx,USE_HAL_DRIVER
  c misc: -mcmse -fno-strict-aliasing -fsigned-char
  c include: .\;..\..\Include;..\..\..\M0A00_Library\STM32Cube_FW_N6_V1.1.0\Drivers\CMSIS\Include;..\..\..\M0A00_Library\STM32Cube_FW_N6_V1.1.0\Drivers\CMSIS\Device\ST\STM32N6xx\Include;..\..\..\M0A00_Library\STM32Cube_FW_N6_V1.1.0\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates;..\..\..\M0A00_Library\STM32Cube_FW_N6_V1.1.0\Drivers\STM32N6xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\rmp_platform_stm32n657x0h3.sct
  link misc: --entry=Reset_Handler
  group Kernel
    ../../Source/Kernel/: rmp_kernel.c
  group Platform
    ../../Source/Platform/A8M/: rmp_platform_a8m.c rmp_platform_a8m_gcc.s
  group Lib
    ./: rmp_platform_stm32n657x0h3_sp.s
    ../../../M0A00_Library/STM32Cube_FW_N6_V1.1.0/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/arm/: startup_stm32n657xx.c
    ../../../M0A00_Library/STM32Cube_FW_N6_V1.1.0/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_s.c
    ../../../M0A00_Library/STM32Cube_FW_N6_V1.1.0/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c
  group Test
    ../../Source/Test/: rmp_benchmark.c
