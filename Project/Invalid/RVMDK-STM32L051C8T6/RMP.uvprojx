# Keil uVision project RMP.uvprojx, settings and files
target RMP (6180000::V6.18::ARMCLANG)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RMP +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32L0xx, USE_HAL_DRIVER
  c misc: -Wno-date-time -Wno-unused-parameter -Wno-missing-variable-declarations -Wno-missing-noreturn -Wno-padded
  c include: .\;..\..\Include;..\..\..\M0A00_Library\STM32Cube_FW_L0_V1.10.0\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\M0A00_Library\STM32Cube_FW_L0_V1.10.0\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\M0A00_Library\STM32Cube_FW_L0_V1.10.0\Drivers\CMSIS\Include;..\..\..\M0A00_Library\STM32Cube_FW_L0_V1.10.0\Drivers\STM32L0xx_HAL_Driver\Inc\Conf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Kernel
    ../../Source/Kernel/: rmp_kernel.c
  group Platform
    ../../Source/Platform/A6M/: rmp_platform_a6m.c rmp_platform_a6m_armcc.s
  group Lib
    ../../../M0A00_Library/STM32Cube_FW_L0_V1.10.0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_dma.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart_ex.c
    ../../../M0A00_Library/STM32Cube_FW_L0_V1.10.0/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ../../../M0A00_Library/STM32Cube_FW_L0_V1.10.0/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l051xx.s
  group Benchmark
    ../../Source/Benchmark/: rmp_test.c
software components: CMSIS:CORE 5.6.0
