# Keil uVision project RTOS-Mutate.uvprojx, settings and files
target RMP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RMP +hex
  BeforeMake: copy.bat
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=2 v6LangP=1 v6Lto=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\MProkaron\Include;..\..\..\M0A00_Library\STM32Cube_FW_F1_V1.6.0\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\M0A00_Library\STM32Cube_FW_F1_V1.6.0\Drivers\CMSIS\Include;..\..\..\M0A00_Library\STM32Cube_FW_F1_V1.6.0\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\M0A00_Library\STM32Cube_FW_F1_V1.6.0\Drivers\STM32F1xx_HAL_Driver\Inc\Conf;..\RVMDK-STM32F103ZET6
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MProkaron
    ../../MProkaron/Kernel/: rmp_kernel.c
  group Platform
    ../../MProkaron/Platform/CortexM/: rmp_platform_cmx.c rmp_platform_cmx_asm.s
  group Lib
    ../../../M0A00_Library/STM32Cube_FW_F1_V1.6.0/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    ../../../M0A00_Library/STM32Cube_FW_F1_V1.6.0/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../../M0A00_Library/STM32Cube_FW_F1_V1.6.0/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c
  group Benchmark
    ../../MProkaron/Benchmark/: rmp_test.c
software components: CMSIS:CORE 5.1.1
