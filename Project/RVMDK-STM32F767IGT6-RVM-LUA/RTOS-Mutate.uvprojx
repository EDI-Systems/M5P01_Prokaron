# Keil uVision project RTOS-Mutate.uvprojx, settings and files
target RMP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: VM_LUA +hex
  BeforeMake: copy.bat
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: bincopy.exe -i $L@L.bin -o $L@L.c
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F767xx,USE_HAL_DRIVER, "lua_writestring=RMP_lua_writestring", "lua_writeline=RMP_lua_writeline"
  c include: ..\..\MProkaron\Include;..\..\..\M7M2_MuAmmonite\MAmmonite\Guest\CortexM;..\..\MProkaron\Include\Platform\CortexM_RVM;..\..\..\M0P0_Library\STM32Cube_FW_F7_V1.11.0\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\M0P0_Library\STM32Cube_FW_F7_V1.11.0\Drivers\STM32F7xx_HAL_Driver\Inc\Conf;..\..\..\M0P0_Library\STM32Cube_FW_F7_V1.11.0\Drivers\CMSIS\Include;..\..\..\M0P0_Library\STM32Cube_FW_F7_V1.11.0\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\M6P1(L)_Lua\lua
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group MProkaron
    ../../MProkaron/Kernel/: kernel.c
  group Platform
    ../../MProkaron/Platform/CortexM_RVM/: platform_cmx_RVM.c platform_cmx_RVM_asm.s
  group Lib
    ../../../M7M2_MuAmmonite/MAmmonite/Guest/CortexM/: guest_cmx.c guest_cmx.s
  group Lua
    ../../../M6P1(L)_Lua/lua/: lapi.c lauxlib.c lbaselib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltests.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group Benchmark
    ./Source/: test_lua.c test_lua.s
software components: CMSIS:CORE 5.0.2
