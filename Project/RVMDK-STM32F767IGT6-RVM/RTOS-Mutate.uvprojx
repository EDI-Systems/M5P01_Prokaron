# Keil uVision project RTOS-Mutate.uvprojx, settings and files
target RMP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: VM1 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: bincopy.exe -i $L@L.bin -o $L@L.c
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F767xx,USE_HAL_DRIVER
  c include: ..\..\MProkaron\Include;..\..\..\..\Library\STM32F7xx_HAL_Driver\Core;..\..\..\..\Library\STM32F7xx_HAL_Driver\Inc;..\..\..\..\Library\STM32F7xx_HAL_Driver\Inc\Conf
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group MProkaron
    ../../MProkaron/Kernel/: kernel.c
  group Platform
    ../../MProkaron/Platform/CortexM_RVM/: platform_cmx_RVM.c platform_cmx_RVM_asm.s
  group Benchmark
    ../../MProkaron/Benchmark/: test.c
software components: CMSIS:CORE 5.0.2
