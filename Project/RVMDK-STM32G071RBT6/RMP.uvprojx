# Keil uVision project RMP.uvprojx, settings and files
target RMP (6230000::V6.23::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(64000000) ELITTLE
  output: RMP +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32G0xx, USE_HAL_DRIVER
  c misc: -Wno-extra-semi-stmt -Wno-date-time -Wno-unused-parameter -Wno-missing-variable-declarations -Wno-missing-noreturn -Wno-padded
  c include: .\;..\..\Include;..\..\..\M0A00_Library\STM32Cube_FW_G0_V1.6.3\Drivers\STM32G0xx_HAL_Driver\Inc;..\..\..\M0A00_Library\STM32Cube_FW_G0_V1.6.3\Drivers\CMSIS\Device\ST\STM32G0xx\Include;..\..\..\M0A00_Library\STM32Cube_FW_G0_V1.6.3\Drivers\CMSIS\Include;..\..\..\M0A00_Library\STM32Cube_FW_G0_V1.6.3\Drivers\STM32G0xx_HAL_Driver\Inc\Conf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Kernel
    ../../Source/Kernel/: rmp_kernel.c
  group Platform
    ../../Source/Platform/A6M/: rmp_platform_a6m.c rmp_platform_a6m_armcc.s
  group Lib
    ../../../M0A00_Library/STM32Cube_FW_G0_V1.6.3/Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_dma.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_cortex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_uart_ex.c
    ../../../M0A00_Library/STM32Cube_FW_G0_V1.6.3/Drivers/CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
    ../../../M0A00_Library/STM32Cube_FW_G0_V1.6.3/Drivers/CMSIS/Device/ST/STM32G0xx/Source/Templates/arm/: startup_stm32g071xx.s
  group Test
    ../../Source/Test/: rmp_benchmark.c
software components: CMSIS:CORE 5.6.0
