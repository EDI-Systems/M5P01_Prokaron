# Keil uVision project RTOS-Mutate.uvprojx, settings and files
target RMP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L13X.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RMP +hex
  BeforeMake: copy.bat
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\MProkaron\Include;..\..\..\M0P0_Library\HC32L13X_DDL_V1.0\driver\inc;..\..\..\M0P0_Library\HC32L13X_DDL_V1.0\mcu\common;..\..\..\M0P0_Library\HC32L13X_DDL_V1.0\driver\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MProkaron
    ../../MProkaron/Kernel/: rmp_kernel.c
  group Platform
    ../../MProkaron/Platform/CortexM/: rmp_platform_cmx.c rmp_platform_cmx_asm.s rmp_platform_cm0_asm.s
  group Lib
    ../../../M0P0_Library/HC32L13X_DDL_V1.0/driver/src/: sysctrl.c interrupts_hc32l13x.c gpio.c timer3.c uart.c
    ../../../M0P0_Library/HC32L13X_DDL_V1.0/mcu/common/: startup_hc32l13x.s system_hc32l13x.c
  group Benchmark
    ../../MProkaron/Benchmark/: rmp_test.c
software components: CMSIS:CORE 5.1.1
