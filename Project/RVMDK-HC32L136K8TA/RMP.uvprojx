# Keil uVision project RMP.uvprojx, settings and files
target RMP (6180000::V6.18::ARMCLANG)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RMP +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=1
  c include: .;..\..\Include;..\..\..\M0A00_Library\HC32L13x_DDL_V2.1.0\driver\inc;..\..\..\M0A00_Library\HC32L13x_DDL_V2.1.0\mcu\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MProkaron
    ../../Source/Kernel/: rmp_kernel.c
  group Platform
    ../../Source/Platform/A6M/: rmp_platform_a6m.c rmp_platform_a6m_armcc.s
  group Lib
    ../../../M0A00_Library/HC32L13x_DDL_V2.1.0/driver/src/: ddl.c sysctrl.c gpio.c timer3.c uart.c
    ../../../M0A00_Library/HC32L13x_DDL_V2.1.0/mcu/common/: interrupts_hc32l13x.c system_hc32l13x.c
    ../../../M0A00_Library/HC32L13x_DDL_V2.1.0/example/adc/adc_scan_jqr_sw/MDK/: startup_hc32l13x.s
  group Benchmark
    ../../Source/Benchmark/: rmp_test.c
software components: CMSIS:CORE 5.6.0
