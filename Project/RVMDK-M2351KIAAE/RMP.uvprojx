# Keil uVision project RMP.uvprojx, settings and files
target RMP (6230000::V6.23::ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(48000000) ELITTLE
  output: RMP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=5 v6LangP=3
  c include: .;..\..\Include;..\..\..\M0A00_Library\M2351BSP\Library\CMSIS\Include;..\..\..\M0A00_Library\M2351BSP\Library\Device\Nuvoton\M2351\Include;..\..\..\M0A00_Library\M2351BSP\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\rmp_platform_m2351kiaae.sct
  link misc: --map --datacompressor=off --info=inline
  group Kernel
    ../../Source/Kernel/: rmp_kernel.c
  group Platform
    ../../Source/Platform/A8MB/: rmp_platform_a8mb.c rmp_platform_a8mb_gcc.s
  group Test
    ../../Source/Test/: rmp_benchmark.c
  group Stubs
    ./: rmp_stubs.c
  group Lib
    ../../../M0A00_Library/M2351BSP/Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.S
    ../../../M0A00_Library/M2351BSP/Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../M0A00_Library/M2351BSP/Library/StdDriver/src/: clk.c sys.c uart.c timer.c
