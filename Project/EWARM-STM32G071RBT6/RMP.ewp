# IAR project RMP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G071xx; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; ..\..\Include; ..\..\..\M0A00_Library\STM32Cube_FW_G0_V1.6.3\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\M0A00_Library\STM32Cube_FW_G0_V1.6.3\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\M0A00_Library\STM32Cube_FW_G0_V1.6.3\Drivers\CMSIS\Include; ..\..\..\M0A00_Library\STM32Cube_FW_G0_V1.6.3\Drivers\STM32G0xx_HAL_Driver\Inc\Conf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RMP.srec
  ILINK.IlinkOutputFile: RMP.out
  ILINK.IlinkIcfFile: stm32g071xB_local.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group HAL
    ../../../M0A00_Library/STM32Cube_FW_G0_V1.6.3/Drivers/CMSIS/Device/ST/STM32G0xx/Source/Templates/iar/: startup_stm32g071xx.s
    ../../../M0A00_Library/STM32Cube_FW_G0_V1.6.3/Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
    ../../../M0A00_Library/STM32Cube_FW_G0_V1.6.3/Drivers/CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
  group Kernel
    ../../Source/Kernel/: rmp_kernel.c
  group Platform
    ../../Source/Platform/A6M/: rmp_platform_a6m.c rmp_platform_a6m_iccarm.s
  group Test
    ../../Source/Test/: rmp_benchmark.c
