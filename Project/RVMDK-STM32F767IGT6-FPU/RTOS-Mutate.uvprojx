# Keil uVision project RTOS-Mutate.uvprojx, settings and files
target RMP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RMP +hex
  BeforeMake: copy.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER
  c include: ..\..\MProkaron\Include;..\..\..\M0A00_Library\STM32Cube_FW_F7_V1.11.0\Drivers\STM32F7xx_HAL_Driver\Core;..\..\..\M0A00_Library\STM32Cube_FW_F7_V1.11.0\Drivers\STM32F7xx_HAL_Driver\Inc;.\Source;.\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group MProkaron
    ../../MProkaron/Kernel/: rmp_kernel.c
  group Platform
    ../../MProkaron/Platform/CortexM/: rmp_platform_cmx.c rmp_platform_cmx_asm.s
  group Lib
    ../../../M0A00_Library/STM32Cube_FW_F7_V1.11.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c
    ../../../M0A00_Library/STM32Cube_FW_F7_V1.11.0/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f767xx.s
    ../../../M0A00_Library/STM32Cube_FW_F7_V1.11.0/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group User
    ./Source/: fulltest.c
software components: CMSIS:CORE 5.1.1
