# Keil uVision project RTOS-Mutate.uvprojx, settings and files
target RMP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RMP +hex
  BeforeMake: copy.bat
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER, HSE_VALUE="8000000", PLL_M="8"
  c include: ..\..\MProkaron\Include;..\..\..\M0P0_Library\STM32F4xx_StdPeriph_Driver\inc;..\..\..\M0P0_Library\STM32F4xx_StdPeriph_Driver\CMSIS\ST\STM32F4xx\Include;..\..\..\M0P0_Library\STM32F4xx_StdPeriph_Driver\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MProkaron
    ../../MProkaron/Kernel/: kernel.c
  group Platform
    ../../MProkaron/Platform/CortexM/: platform_cmx.c platform_cmx_asm.s
  group Lib
    ../../../M0P0_Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../../../M0P0_Library/STM32F4xx_StdPeriph_Driver/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../../../M0P0_Library/STM32F4xx_StdPeriph_Driver/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Benchmark
    ../../MProkaron/Benchmark/: test.c
software components: CMSIS:CORE 5.0.2
